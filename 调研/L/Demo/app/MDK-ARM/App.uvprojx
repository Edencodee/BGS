# Keil uVision project App.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L403KB NSING
  pack: NSING.N32L40x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER,LED=1, PB=1,DEBUG=1,APP,BOOT_EN
  c include: ..\inc;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32l40x_std_periph_driver\inc;..\..\bsp\inc;..\..\RTT;..\..\API\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group USER
    ../src/: atsp.c filter.c main.c modbus.c n32l40x_it.c task.c task_btn.c task_flash.c task_led.c task_measure.c task_output.c task_short.c
  group BSP
    ../../bsp/src/: systick.c user_flash.c user_gpio.c user_uart.c user_i2c.c user_tim.c user_fdog.c
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group DOC
    ../: readme.txt
  group API
    ../../API/src/: vl53lx_api.c vl53lx_api_calibration.c vl53lx_api_core.c vl53lx_api_debug.c vl53lx_api_preset_modes.c vl53lx_core.c vl53lx_core_support.c vl53lx_dmax.c vl53lx_hist_algos_gen3.c vl53lx_hist_algos_gen4.c vl53lx_hist_char.c vl53lx_hist_core.c vl53lx_hist_funcs.c vl53lx_nvm.c vl53lx_nvm_debug.c vl53lx_platform.c vl53lx_platform_ipp.c vl53lx_platform_log.c vl53lx_sigma_estimate.c vl53lx_silicon_core.c vl53lx_wait.c vl53lx_xtalk.c vl53lx_register_funcs.c vl53lx_zone_presets.c
