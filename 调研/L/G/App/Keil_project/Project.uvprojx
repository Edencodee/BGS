# Keil uVision project Project.uvprojx, settings and files
target GD32C231 (6210000::V6.21::ARMCLANG)
  device: GD32C231C8 GigaDevice
  pack: GigaDevice.GD32C2x1_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0003000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C231
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Firmware\GD32C2x1_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32C2x1\Include;..\..\Utilities\inc;..\..\RTT;..\..\ISL700_2A_38VC_Fuse
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application
    ../: main.c systick.c gd32c2x1_it.c task.c task_PD.c task_led.c task_flash.c task_output.c task_short.c filter.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C2x1/Source/: gd32c2x1_err_report.c system_gd32c2x1.c
  group Peripherals
    ../../Firmware/GD32C2x1_standard_peripheral/Source/: gd32c2x1_adc.c gd32c2x1_cmp.c gd32c2x1_crc.c gd32c2x1_dbg.c gd32c2x1_dma.c gd32c2x1_exti.c gd32c2x1_fmc.c gd32c2x1_fwdgt.c gd32c2x1_gpio.c gd32c2x1_misc.c gd32c2x1_i2c.c gd32c2x1_pmu.c gd32c2x1_rcu.c gd32c2x1_rtc.c gd32c2x1_spi.c gd32c2x1_syscfg.c gd32c2x1_timer.c gd32c2x1_usart.c gd32c2x1_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32C2x1/Source/ARM/: startup_gd32c231_221.s
  group Utilities
    ../../Utilities/src/: user_adc.c user_gpio.c user_timer.c user_flash.c user_uart.c
  group Doc
    ../: readme.txt
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middress
    ../../ISL700_2A_38VC_Fuse/: CRC_8.C ISL700_2A_38VC.c
target GD32C221 (6160000::V6.16::ARMCLANG)
  device: GD32C221C8 GigaDevice
  pack: GigaDevice.GD32C2x1_DFP.1.0.0
  cpu: as above
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C221
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Firmware\GD32C2x1_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32C2x1\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
software components: CMSIS:CORE 5.5.0
