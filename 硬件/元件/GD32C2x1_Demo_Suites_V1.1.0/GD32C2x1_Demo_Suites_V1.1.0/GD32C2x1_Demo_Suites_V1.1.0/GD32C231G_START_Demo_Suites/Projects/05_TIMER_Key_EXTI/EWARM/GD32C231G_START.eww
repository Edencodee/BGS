<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GD32C231G_START.ewp</path>
    </project>
    <batchBuild />
</workspace>
